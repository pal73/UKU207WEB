# Keil uVision project UKU.uvproj, settings and files
target UKU (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU_WEB +hex
  BeforeMake: python curr_version.py
  c flags: Optim=2
  c define: UKU_220_IPS_TERMOKOMPENSAT, UKU2071x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP
    ./WEB/: web.inp
  group Startup
    ./: startup_LPC17xx.s Net_Config_HTTP.c
  group Source
    ./: common_func.c control.c mess.c ret.c gran.c avar_hndl.c eeprom_map.c cmd.h main.c simbols.c graphic.c snmp_data_file.c SNMP_MIB.c curr_version.c sntp.c HTTP_CGI.c
  group System
    ./: memo.c system_LPC17xx.c Timer.c
  group Target
    ./: beep.c ad7705.c lcd_AGM1232_uku207_3.c 25lc640.c
    ./WEB/: Web.c
  group Connecting
    ./: full_can.c uart0.c modbus.c uart2.c bat_driver.c mcp2515.c sacred_sun.c sc16is7xx.c ztt.c MODBUS_TCP.c uart1.c
  group Library
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
